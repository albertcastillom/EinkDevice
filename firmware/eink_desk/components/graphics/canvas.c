#include "canvas.h"

#include <string.h>

// Five-column glyphs for printable ASCII characters from space through Z.
static const uint8_t FONT_5X7[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5f, 0x00, 0x00},
    {0x00, 0x07, 0x00, 0x07, 0x00}, {0x14, 0x7f, 0x14, 0x7f, 0x14},
    {0x24, 0x2a, 0x7f, 0x2a, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00},
    {0x00, 0x1c, 0x22, 0x41, 0x00}, {0x00, 0x41, 0x22, 0x1c, 0x00},
    {0x14, 0x08, 0x3e, 0x08, 0x14}, {0x08, 0x08, 0x3e, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08},
    {0x00, 0x60, 0x60, 0x00, 0x00}, {0x20, 0x10, 0x08, 0x04, 0x02},
    {0x3e, 0x51, 0x49, 0x45, 0x3e}, {0x00, 0x42, 0x7f, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4b, 0x31},
    {0x18, 0x14, 0x12, 0x7f, 0x10}, {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3c, 0x4a, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1e},
    {0x00, 0x36, 0x36, 0x00, 0x00}, {0x00, 0x56, 0x36, 0x00, 0x00},
    {0x08, 0x14, 0x22, 0x41, 0x00}, {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06},
    {0x32, 0x49, 0x79, 0x41, 0x3e}, {0x7e, 0x11, 0x11, 0x11, 0x7e},
    {0x7f, 0x49, 0x49, 0x49, 0x36}, {0x3e, 0x41, 0x41, 0x41, 0x22},
    {0x7f, 0x41, 0x41, 0x22, 0x1c}, {0x7f, 0x49, 0x49, 0x49, 0x41},
    {0x7f, 0x09, 0x09, 0x09, 0x01}, {0x3e, 0x41, 0x49, 0x49, 0x7a},
    {0x7f, 0x08, 0x08, 0x08, 0x7f}, {0x00, 0x41, 0x7f, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3f, 0x01}, {0x7f, 0x08, 0x14, 0x22, 0x41},
    {0x7f, 0x40, 0x40, 0x40, 0x40}, {0x7f, 0x02, 0x0c, 0x02, 0x7f},
    {0x7f, 0x04, 0x08, 0x10, 0x7f}, {0x3e, 0x41, 0x41, 0x41, 0x3e},
    {0x7f, 0x09, 0x09, 0x09, 0x06}, {0x3e, 0x41, 0x51, 0x21, 0x5e},
    {0x7f, 0x09, 0x19, 0x29, 0x46}, {0x46, 0x49, 0x49, 0x49, 0x31},
    {0x01, 0x01, 0x7f, 0x01, 0x01}, {0x3f, 0x40, 0x40, 0x40, 0x3f},
    {0x1f, 0x20, 0x40, 0x20, 0x1f}, {0x3f, 0x40, 0x38, 0x40, 0x3f},
    {0x63, 0x14, 0x08, 0x14, 0x63}, {0x07, 0x08, 0x70, 0x08, 0x07},
    {0x61, 0x51, 0x49, 0x45, 0x43},
};

bool canvas_init(canvas_t *canvas, uint8_t *pixels, size_t buffer_size, uint16_t width, uint16_t height)
{
    if (canvas == NULL || pixels == NULL || width == 0 || height == 0) return false;
    const uint16_t stride = (uint16_t)((width + 7U) / 8U);
    if (buffer_size < (size_t)stride * height) return false;
    *canvas = (canvas_t){
        .pixels = pixels,
        .width = width,
        .height = height,
        .stride = stride,
        .storage_width = width,
        .storage_height = height,
        .buffer_size = buffer_size,
        .rotation = CANVAS_ROTATION_0,
    };
    return true;
}

void canvas_set_rotation(canvas_t *canvas, canvas_rotation_t rotation)
{
    if (canvas == NULL) return;
    canvas->rotation = rotation;
    if (rotation == CANVAS_ROTATION_90 || rotation == CANVAS_ROTATION_270) {
        canvas->width = canvas->storage_height;
        canvas->height = canvas->storage_width;
    } else {
        canvas->width = canvas->storage_width;
        canvas->height = canvas->storage_height;
    }
}

void canvas_clear(canvas_t *canvas, bool black)
{
    if (canvas != NULL && canvas->pixels != NULL) memset(canvas->pixels, black ? 0x00 : 0xff, canvas->buffer_size);
}

void canvas_set_pixel(canvas_t *canvas, int x, int y, bool black)
{
    if (canvas == NULL || canvas->pixels == NULL || x < 0 || y < 0 || x >= canvas->width || y >= canvas->height) return;
    int storage_x = x;
    int storage_y = y;
    if (canvas->rotation == CANVAS_ROTATION_90) {
        storage_x = canvas->storage_width - 1 - y;
        storage_y = x;
    } else if (canvas->rotation == CANVAS_ROTATION_270) {
        storage_x = y;
        storage_y = canvas->storage_height - 1 - x;
    }
    const size_t index = (size_t)storage_y * canvas->stride + (size_t)storage_x / 8U;
    const uint8_t mask = (uint8_t)(0x80U >> (storage_x % 8));
    if (black) canvas->pixels[index] &= (uint8_t)~mask;
    else canvas->pixels[index] |= mask;
}

void canvas_fill_rect(canvas_t *canvas, int x, int y, int width, int height, bool black)
{
    if (width <= 0 || height <= 0) return;
    for (int py = y; py < y + height; ++py)
        for (int px = x; px < x + width; ++px) canvas_set_pixel(canvas, px, py, black);
}

void canvas_draw_rect(canvas_t *canvas, int x, int y, int width, int height, int thickness)
{
    if (width <= 0 || height <= 0 || thickness <= 0) return;
    canvas_fill_rect(canvas, x, y, width, thickness, true);
    canvas_fill_rect(canvas, x, y + height - thickness, width, thickness, true);
    canvas_fill_rect(canvas, x, y, thickness, height, true);
    canvas_fill_rect(canvas, x + width - thickness, y, thickness, height, true);
}

void canvas_draw_char(canvas_t *canvas, int x, int y, char character, int scale)
{
    if (scale <= 0) return;
    if (character >= 'a' && character <= 'z') character = (char)(character - 'a' + 'A');
    if (character < ' ' || character > 'Z') character = '?';
    const uint8_t *glyph = FONT_5X7[(unsigned char)character - ' '];
    for (int column = 0; column < 5; ++column)
        for (int row = 0; row < 7; ++row)
            if ((glyph[column] & (1U << row)) != 0)
                canvas_fill_rect(canvas, x + column * scale, y + row * scale, scale, scale, true);
}

void canvas_draw_text(canvas_t *canvas, int x, int y, const char *text, int scale)
{
    if (text == NULL) return;
    while (*text != '\0') {
        canvas_draw_char(canvas, x, y, *text, scale);
        x += 6 * scale;
        ++text;
    }
}
